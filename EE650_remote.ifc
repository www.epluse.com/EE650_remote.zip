Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: Thu Aug 13 07:59:04 2020
Author: at3107
Written by: PTC Creo 1.0
Made in: PTC

# IfcProject, Default Project
LongName: Project Status; Phase: Project Status

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Part, EE650_R
In: Default Storey
PTC_Identity Data - DEVICENAME: Air Flow Sensor for HVAC / Remote Probe; MEASURAND1: Air Velocity; Working range 0…20 m/s; OUTPUT1: Analogue voltage / current; 0-10 V / 4-20 mA (2-wire); OUTPUT2: Digital interface; RS485 with Modbus RTU or BACnet MS/TP; SUPPLY: 24 V AC / DC ±20 %; ENCLOSUREMATERIAL: Polycarbonate / UL94V-0 approved / IP20; ENCLOSUREDIMENSIONS: WxHxD = 80.6x101x46 mm (3.17x3.98x1.81"); ENCLOSUREDESIGNSTANDARD: Cover: light grey RAL7035; housing: E+E green RAL6018; VOLUME: 380481; SURFACE_AREA: 46120.1; MASS: 380481; DENSITY: 1; CENTRE_OF_GRAVITY_X: 21.1277; CENTRE_OF_GRAVITY_Y: 1.7859; CENTRE_OF_GRAVITY_Z: 29.6733
